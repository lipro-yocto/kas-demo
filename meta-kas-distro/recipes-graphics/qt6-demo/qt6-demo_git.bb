require qt6_demo.inc

SRCREV = "${AUTOREV}"
S = "${WORKDIR}/git"
